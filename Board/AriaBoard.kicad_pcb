# Repository AssociazionePrometeo/AriaBoard

## KiCad design Board/AriaBoard.kicad_pcb

Parts:
BT1: BATTERY
F1, F2: FUSE
J1: USB_MICRO
J2: HR911105_RJ45
P1, P2: CONN_2
P3, P11: CONN_4
P4, P5: CONN_5
P6: CONN_6
P7, P9: CONN_8
P8: CONN_10
P10: CONN_9
P12, P13, P14: CONN_4
R12, R13, R14, R15, R16, R17, R18, R19, R20: 0
SW1: SOLDER_SWITCH
SW2: SW_PUSH
U1: DS18S20
U2: MICROSDCARD
U3: ARIAG25; Aria-G25

Connections:
+5V: F1.2, R12.1, R13.1
/1-Wire: P5.1, U1.2 (DQ), U3.S2 (1-Wire)
/3v_aria: R17.2, U3.E24 (3V3), U3.N1 (3V3), U3.S1 (3V3), U3.W24 (3V3)
/3v_ext: R16.2, U1.3 (Vdd), U2.4 (VDD)
/5v_usb: P12.4, P13.4, P14.4, R13.2
/A/D_VREF_input: P4.5, U3.W19 (A/D_VREF_input)
/AD0: P4.4, U3.W20 (AD0)
/AD1: P4.3, U3.W21 (AD1)
/AD2: P4.2, U3.W22 (AD2)
/AD3: P4.1, U3.W23 (AD3)
/CTS0_ttyS1: P11.4, U3.S20 (CTS0_ttyS1)
/CTS1_ttyS2: P6.1, U3.E8 (CTS1_ttyS2)
/CTS3: P6.3, U3.E5 (CTS3)
/FTDI_Debug_port/+3V: R18.2; also elsewhere on the board
/FTDI_Debug_port/+5V: R12.2; also elsewhere on the board
/FTDI_Debug_port/D_RXD: U3.S13 (Debug_port_TXD); also elsewhere on the board
/FTDI_Debug_port/D_TXD: U3.S14 (Debug_port_RXD); also elsewhere on the board
/FTDI_Debug_port/RST: SW2.1, U3.E21 (Reset); also elsewhere on the board
/FTDI_Debug_port/USB_D+: J1.3; also elsewhere on the board
/FTDI_Debug_port/USB_D-: J1.2; also elsewhere on the board
/FTDI_Debug_port/USB_PWR: J1.1; also elsewhere on the board
/GPIO_36: P8.1, U3.S19 (GPIO_36)
/GPIO_54: P8.2, U3.W9 (GPIO_54)
/GPIO_55: P8.3, U3.W10 (GPIO_55)
/GPIO_56: P8.4, U3.W11 (GPIO_56)
/GPIO_57: P8.5, U3.W12 (GPIO_57)
/GPIO_58: P8.6, U3.W13 (GPIO_58)
/GPIO_59: P8.7, U3.W14 (GPIO_59)
/GPIO_60: P8.8, U3.W15 (GPIO_60)
/GPIO_61: P8.9, U3.W16 (GPIO_61)
/GPIO_96: P8.10, U3.N2 (GPIO_96)
/GPIO_97: P10.1, U3.N3 (GPIO_97)
/GPIO_98: P10.2, U3.N4 (GPIO_98)
/GPIO_99: P10.3, U3.N5 (GPIO_99)
/GPIO_100: P10.4, U3.N6 (GPIO_100)
/GPIO_101: P10.5, U3.N7 (GPIO_101)
/GPIO_102: P10.6, U3.N8 (GPIO_102)
/GPIO_103: P10.7, U3.N9 (GPIO_103)
/GPIO_104: P10.8, U3.N10 (GPIO_104)
/GPIO_105: P10.9, U3.N11 (GPIO_105)
/GPIO_106: P9.8, U3.N12 (GPIO_106)
/GPIO_107: P9.7, U3.N13 (GPIO_107)
/GPIO_108: P9.6, U3.N14 (GPIO_108)
/GPIO_109: P9.5, U3.N15 (GPIO_109)
/GPIO_110: P9.4, U3.N16 (GPIO_110)
/GPIO_111: P9.3, U3.N17 (GPIO_111)
/GPIO_112: P9.2, U3.N18 (GPIO_112)
/GPIO_113: P9.1, U3.N19 (GPIO_113)
/GPIO_114: P7.8, U3.N20 (GPIO_114)
/GPIO_115: P7.7, U3.N21 (GPIO_115)
/GPIO_116: P7.6, U3.N22 (GPIO_116)
/GPIO_117: P7.5, U3.N23 (GPIO_117)
/GPIO_122: P7.4, U3.E6 (GPIO_122)
/GPIO_125: P7.3, U3.E9 (GPIO_125)
/GPIO_126: P7.2, U3.E10 (GPIO_126)
/GPIO_127: P7.1, U3.E11 (GPIO_127)
/I2C-0_CLOCK: P2.1, U3.W18 (I2C-0_CLOCK)
/I2C_0_DATA: P2.2 (PM), U3.W17 (I2C-0_DATA)
/RTS0_ttyS1: P11.3, U3.S21 (RTS0_ttyS1)
/RTS1_ttyS2: P6.2, U3.E7 (RTS1_ttyS2)
/RTS3: P6.4, U3.E4 (RTS3)
/RXD0_ttyS1: P11.2, U3.S22 (RXD0_ttyS1)
/RXD1_ttyS2: P3.2, U3.S17 (RXD1_ttyS2)
/RXD2_ttyS3: P3.3, U3.S15 (RXD2_ttyS3)
/RXD3_tty4: P6.5, U3.E3 (RXD3_ttyS4)
/SPI-0_MISO: P5.5, U3.S12 (SPI-0_MISO)
/SPI-0_MOSI: P5.4, U3.S11 (SPI-0_MOSI)
/SPI-0_SPCK: P5.3, U3.S10 (SPI-0_SPCK)
/SPI_0_NPCSD: P5.2, U3.S9 (SPI-0_NPCS0)
/TXD0_ttyS1: P11.1, U3.S23 (TXD0_ttyS1)
/TXD1_ttyS2: P3.1, U3.S18 (TXD1_ttyS2)
/TXD2_ttyS3: P3.4, U3.S16 (TXD2_ttyS3)
/TXD3_tty4: P6.6, U3.E2 (TXD3_ttyS4)
/USB-A_D+: P12.2, U3.E19 (USB-A_D+)
/USB-A_D-: P12.3, U3.E18 (USB-A_D-)
/USB-B_D+: P13.2, U3.E16 (USB-B_D+)
/USB-B_D-: P13.3, U3.E15 (USB-B_D-)
/USB-C_D+: P14.2, U3.E12 (USB-C_D+)
/USB-C_D-: P14.3, U3.E13 (USB-C_D-)
/Voltage_Regulation_5V/+5V: F1.1; also elsewhere on the board
/Voltage_Regulation_5V/VIN: R19.1; also elsewhere on the board
/Voltage_regulation_3V/+3V: R16.1, R17.1, R18.1; also elsewhere on the board
/Voltage_regulation_3V/VIN: R20.2; also elsewhere on the board
/clk: U2.5 (CLK), U3.S6 (SD_card_CK)
/cs: U2.1 (CS), U3.S4 (SD_card_DA2)
/di: U2.2 (DI), U3.S3 (SD_card__DA3)
/do: U2.7 (DO), U3.S8 (SD_card_DA0)
/eth_3v3: J2.4 (CT_TX), J2.5 (CT_R), U3.W6 (ETH_3V3)
/eth_l1: J2.11 (Y_LED_K), U3.W8 (ETH_link_led)
/eth_l2: J2.12 (Y_LED_A), U3.W7 (ETH_traffic_led)
/nc: U2.8 (NC), U3.S5 (SD_card_DA1)
/rd+: J2.3 (RD+), U3.W2 (ETH_RX+)
/rd-: J2.6 (RD-), U3.W3 (ETH_RX-)
/td+: J2.1 (TD+), U3.W4 (ETH_TX+)
/td-: J2.2 (TD-), U3.W5 (ETH_TX-)
/vbat: BT1.1 (+), U3.E20 (VBAT)
/vss: U2.3 (VSS), U3.S7 (SD_card_CDA)
DGND: R14.1, U1.1 (GND), U3.E1 (GND), U3.N24 (GND), U3.S24 (GND), U3.W1 (GND)
unnamed: P1.1, R15.2
unnamed: P1.2 (PM), SW1.3 (ALT)
unnamed: F2.1, SW1.1 (IN)
PGND: BT1.2 (-), J1.5, J2.9 (GR_LED_A), J2.10 (GR_LED_K), P12.1, P13.1, P14.1, R14.2, R15.1, SW2.2, U2.6 (VSS), U3.E14 (GND), U3.E17 (GND); also elsewhere on the board
VCC: F2.2, R19.2, R20.1

Notes on the sheet:
Grounds, Power Switch, Power Jumper and balance resistors
Button Battery for RTC

Parts:
C2: 10uF/25V
C3: 0.1uF
C4: 3.3nF
C5: 10nF
C6: 22uF 6.3v
R2: 100K
R3: 6.8K
R4: 10K 1%
R5: 44.2K 1%
U4: MP2307
U5: INDUCTOR_SMALL

Connections:
/Voltage_Regulation_5V/+5V: C6.1, R5.2, U5.2; also elsewhere on the board
/Voltage_Regulation_5V/VIN: C2.1, R2.1, U4.2 (IN); also elsewhere on the board
unnamed: C4.1, R3.2
unnamed: C3.1, U4.8 (SS)
unnamed: R4.1, R5.1, U4.5 (FB)
unnamed: C4.2, U4.6 (COMP)
unnamed: C5.2, U4.1 (BS)
unnamed: C5.1, U4.3 (SW), U5.1
unnamed: R2.2, U4.7 (EN)
PGND: C2.2, C3.2, C6.2, R3.1, R4.2, U4.4 (GND); also elsewhere on the board

Parts:
C7: 10uF/25V
C8: 0.1uF
C9: 3.3nF
C10: 10nF
C11: 22uF 6.3v
R6: 100K
R7: 6.8K
R8: 10K 1%
R9: 26.1K 1%
U6: MP2307
U7: INDUCTOR_SMALL

Connections:
/Voltage_regulation_3V/+3V: C11.1, R9.2, U7.2; also elsewhere on the board
/Voltage_regulation_3V/VIN: C7.1, R6.1, U6.2 (IN); also elsewhere on the board
unnamed: C10.1, U6.3 (SW), U7.1
unnamed: R8.1, R9.1, U6.5 (FB)
unnamed: C9.1, R7.2
unnamed: C9.2, U6.6 (COMP)
unnamed: C10.2, U6.1 (BS)
unnamed: R6.2, U6.7 (EN)
unnamed: C8.1, U6.8 (SS)
PGND: C7.2, C8.2, C11.2, R7.1, R8.2, U6.4 (GND); also elsewhere on the board

Parts:
C12, C13: 0.1uF
CP1: 10uF
D1, D2: LED
R10, R11: 270
U8: FT232RL

Connections:
/FTDI_Debug_port/+3V: U8.4 (VCCIO); also elsewhere on the board
/FTDI_Debug_port/+5V: R10.1, R11.1; also elsewhere on the board
/FTDI_Debug_port/D_RXD: U8.5 (RXD); also elsewhere on the board
/FTDI_Debug_port/D_TXD: U8.1 (TXD); also elsewhere on the board
/FTDI_Debug_port/RST: U8.19 (RESET); also elsewhere on the board
/FTDI_Debug_port/USB_D+: U8.15 (USBD+); also elsewhere on the board
/FTDI_Debug_port/USB_D-: U8.16 (USBD-); also elsewhere on the board
/FTDI_Debug_port/USB_PWR: C12.2, CP1.1, U8.20 (VCC); also elsewhere on the board
unnamed: C13.1, U8.17 (3V3OUT)
unnamed: D1.2 (K), U8.23 (CBUS0)
unnamed: D2.2 (K), U8.22 (CBUS1)
unnamed: D2.1 (A), R11.2
unnamed: D1.1 (A), R10.2
PGND: C12.1, C13.2, CP1.2, U8.7 (GND), U8.18 (GND), U8.21 (GND), U8.25 (AGND), U8.26 (TEST); also elsewhere on the board

Board: 2 copper layers, 108.7 x 74.9 mm, 67 parts (2 on the bottom side), 121 nets.

Other parts of the board:
MOUNTING_HOLE: VAL**; MOUNTING_HOLE_M2
MOUNTING_HOLE#2, MOUNTING_HOLE#3, MOUNTING_HOLE#4: VAL**; MOUNTING_HOLE_M2

## Commit log

2015-03-12 new chematic work in progress
2015-03-21 added 3.3v 3A breakoutboard based on MP2307
2015-03-25 edited the schematic, and added: separate power line for a different component (5v and 3.3v), fuses, balance resistor, separate ground for digital output.
2015-03-25 add gitignore
2015-04-13 First partial routing
2015-04-14 routing in progress
2015-04-15 Routing finished! Ready to testing and debug
2015-04-17 Added Ariaboard Jpeg image

Notices in the files:
Board/AriaBoard.kicad_pcb:
Released under License CC BY-SA 4.0
